<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\f100_step_motor.ewp</path>
    </project>
    <batchBuild />
</workspace>
