# IAR project f100_step_motor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100RB ST STM32F100RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32F1; STM32F100xB
  ICCARM.CCIncludePath2: ..\; ..\project; ..\project\modules; ..\project\modules\stm32; ..\project\mdl_config; ..\project\application; ..\project\ST; ..\project\ST\core; ..\project\ST\ll
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../project/: main.c
  group application
    ../project/application/: app_uart.c app_uart.h system_init.c system_init.h
  group stm32/CMSIS
    ../project/ST/core/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm1.h core_cm3.h mpu_armv7.h mpu_armv8.h startup_stm32f100xb.s stm32f100xb.h stm32f1xx.h system_stm32f1xx.c system_stm32f1xx.h
  group stm32/ll
    ../project/ST/ll/: stm32f1xx_ll_bus.h stm32f1xx_ll_cortex.h stm32f1xx_ll_crc.c stm32f1xx_ll_crc.h stm32f1xx_ll_dma.c stm32f1xx_ll_dma.h stm32f1xx_ll_exti.c stm32f1xx_ll_exti.h stm32f1xx_ll_gpio.c stm32f1xx_ll_gpio.h stm32f1xx_ll_pwr.c stm32f1xx_ll_pwr.h stm32f1xx_ll_rcc.c stm32f1xx_ll_rcc.h stm32f1xx_ll_system.h stm32f1xx_ll_tim.c stm32f1xx_ll_tim.h stm32f1xx_ll_usart.c stm32f1xx_ll_usart.h stm32f1xx_ll_utils.c stm32f1xx_ll_utils.h
